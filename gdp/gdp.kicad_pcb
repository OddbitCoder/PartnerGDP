# Repository OddbitCoder/PartnerGDP (continued)

## KiCad design gdp/gdp.kicad_pcb (continued)

Board: 4 copper layers, 270.5 x 160.0 mm, 223 parts (0 on the bottom side), 330 nets.

File gdp/bom.txt:

CK1,CK2,CK3,CK4,CK5,CK6,CK7,CK8,CK9,CK10,CK11,CK12,CK13,CK14,CK15,CK16,CK17,CK18,CK19,CK20,CK21,CK22,CK24,CK25,CK26,CK27,CK28,CK29,CK30,CK31,CK32,CK33,CK34,CK35,CK36,CK37,CK38,CK39,CK40,CK41,CK42,CK43,CK44,CK45,CK46,CK47,CK48,CK49,CK50,CK51,CK54,CK56,CK57,CK58,CK59,CK60,CK61 57      U10
CK23    1       10U
CK52    1       22P
CK53    1       U22
CK55    1       2N2
CK62    1       22U
CK63    1       10P
CK64,CK65       2       ~
IC1,IC65        2       74LS74  pins=14
IC2     1       74LS42  pins=16
IC3     1       LM393   pins=8
IC4,IC15        2       74LS367 pins=16
IC5     1       SCN2674 pins=40
IC6     1       74LS85  pins=16
IC7,IC22        2       PAL16L8 pins=20
IC8,IC16        2       74LS245 pins=20
IC9,IC21,IC26,IC27,IC28,IC35,IC48       7       74LS374 pins=20
IC10,IC14       2       74LS83  pins=16
IC11,IC63       2       7406    pins=14
IC12,IC49       2       PAL16R4 pins=20
IC13,IC18,IC25,IC32,IC33,IC34   6       74LS244 pins=20
IC17    1       MK3881  pins=40
IC19,IC20,IC44,IC45,IC47        5       HM6116  pins=24
IC23    1       EF9367  pins=40
IC24    1       PAL10L8 pins=20
IC29,IC30       2       74LS538 pins=20
IC36,IC37,IC38,IC39,IC40,IC41,IC42,IC43,IC53,IC54,IC55,IC56,IC57,IC58,IC59,IC60 16      4164-15 pins=16
IC46    1       2732    pins=24
IC50    1       SCB2675 pins=40
IC51    1       74LS14  pins=14
IC52    1       74LS00  pins=14
IC61    1       74LS163 pins=16
IC64    1       74LS123 pins=16
IC66    1       74S00   pins=14
IC67,IC69       2       74LS166 pins=16
IC68,IC70       2       74LS30  pins=14
IC71,IC72       2       74LS04  pins=14
O1      1       Crystal
R1,R2,R3,R4,R5,R6,R25,R28,R42,R48,R51   11      1K0
R7,R14,R16,R17,R18,R19,R20,R22,R23,R32,R33,R35,R36,R45,R49,R52,R53,R55,R56      19      2K2
R8,R9,R10,R11,R12       5       10K
R13     1       3K3
R15,R21 2       330R
R24     1       120R
R26     1       47R
R27,R29 2       220R
R30,R31 2       75R
R34,R50,R54     3       470R
R37,R44 2       1K5
R38     1       1K8
R39     1       180R
R40     1       50R
R41,R46 2       1K2
R43     1       680R
R47     1       820R
RN1,RN2,RN3     3       8x2K2
SH1,SH2,SH4,SH5,SH6,SH7,SH8,SH9,SH10,SH11,SH12,SH13,SH14,SH15,SH16,SH17,SH18,SH19       18      SCHALT
ST1,ST2 2       6
ST3,ST7 2       10
ST4,ST5 2       32
ST6     1       3
ST8     1       Conn_01x01
T1,T2   2       2N2905A

## Commit log (part)

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2023-09-29 EOD commit
2023-09-29 Adds docs
2023-09-29 Adds more pages, adds schema revisions
2023-10-02 Adds SCB2675 spec
2023-10-02 Adds pages 4, 7, 10 (still WIP)
2023-10-02 Fixes sheet sizes
2023-10-05 Adds pg 13 (WIP)
2023-10-05 Adds all page titles
2023-10-05 Rmv guidelines (rects)
2023-10-08 Some minor edits
2023-10-08 Adds page 2 (created by Tomaz)
2025-01-11 Adds Sheet 3
2025-01-11 Adds Sheet 5
2025-01-11 Adds Sheet 6
2025-01-11 Fixes Sheet 7
2025-01-11 Adds Sheet 8
2025-01-11 Fixes Sheet 5
2025-01-11 Adds Sheet 9
2025-01-12 Adds Sheet 11
2025-01-12 Adds Sheet 12
2025-01-12 Fixes IC references
2025-01-14 Adds component placement and board pictures
2025-01-15 Adds IC values
2025-01-15 Small fixes
2025-01-15 Fixes (component refs...)
2025-01-16 Adds Sheet 14 (WIP)
2025-01-16 Updates placement doc
2025-01-17 Adds Sheet 14
2025-01-17 Fixes IC15
2025-01-17 Fixes Sheet 4
2025-01-18 Initial footprint assignment
2025-01-18 Minor fix
2025-01-18 Results of some measurements
2025-01-18 Several fixes
2025-01-18 Adds VCC/GND
2025-01-20 Adds reference images
2025-01-21 Fixes references
2025-01-21 Fixes refs
2025-01-22 Placing footprints...
2025-01-22 Fixes silkscreen
2025-01-25 Fixes footprints (PCB only)
2025-01-27 Text & ST1
2025-01-28 Maps footprints PCB -> sch
2025-01-28 Minor fix/revert
2025-01-28 Fixes footprint references in sch
2025-01-28 Fixes Sheet 2 symbols
2025-01-28 Final fixes
2025-01-28 Schema fixes
2025-01-28 Re-annotates symbols
2025-01-28 Adds traces
2025-01-29 Adds more copper
2025-01-29 Fixes footprints R34 R27
2025-01-29 Bug fix
2025-01-29 Adjusts pad sizes
2025-01-29 Fixes RN pin numbers
2025-01-30 Fixes resistor footprints
2025-01-31 Adds copper (no nets)
2025-01-31 Fixes labels
2025-01-31 Fixes GND
2025-01-31 Adds GND copper layer
2025-01-31 Fixes ST1
2025-01-31 Fixes SH ref
2025-01-31 Places SH (SH3 missing)
2025-01-31 Adds texts
2025-01-31 Adds (red) copper
2025-01-31 Adds validation ideas/plan
2025-01-31 Adds script for removing nets
2025-02-03 Fixes GND layer
2025-02-03 Adds decoupling capacitors
2025-02-03 Places CKs
2025-02-03 Fixes CK orientation
2025-02-04 Fixes GND layer rect
2025-02-04 Adds missing GND
2025-02-04 Fixes R24/R25
2025-02-04 Fixes SilkS
2025-02-04 Adds GND validation images
2025-02-04 Fixes GND issue (R32)
2025-02-05 Adds R55 & R56
2025-02-05 Excludes SH3 from the board
2025-02-05 Updates GND validation report
2025-02-05 Adds pin 1x1
2025-02-06 Starting PWR layer
2025-02-06 Connects 1x1 pin to IC17
2025-04-11 Adds PCB layers and track widths
2025-04-11 Adds red copper
2025-04-13 EOD commit ASCD2 - looks funky ATTD2 - not good CA1 - not good CA4 - not good XORM - broken
2025-04-13 Some fixups
2025-04-13 Fixing nets one by one IC17-~{CE} - not OK Last net checked IC13A-O2 (sorted by name asc)
2025-04-13 Fixing nets one by one IC15A-2I2
2025-04-13 Fixing nets one by one IC63-Pad2
2025-04-13 Fixing nets one by one Finished pass 1 - 14 unrouted left
2025-04-13 Fixing nets one by one - down to 2 unrouted connections
2025-04-14 Fixes "CA0" issue in schematics
2025-04-14 Prettify green layer
2025-04-14 Cleaned up green layer
2025-04-14 Green layer fixed up to first "5V barrier", left-to-right
2025-04-14 Green layer fixed up to second "5V barrier", left-to-right
2025-04-14 Polish green PCB, upper right remaining
2025-04-14 Green layer 1st pass done
2025-04-14 Green copper polish done
2025-04-14 Down to 10 warns, 1 error
2025-04-15 Small fixes green layer
2025-04-15 Polishing red layer, done below and left to IC5 (IC5 excluded)
2025-04-15 IC5 red layer polish done
2025-04-16 Red layer polishing
2025-04-17 Got myself into a mess.... :(
2025-04-17 Fixes unconnected pads
2025-04-17 Works around KiCad bug (net naming)
2025-04-17 Adds CK65
2025-04-17 Adds CK64
2025-04-17 Some polishing
2025-04-18 Minor change
2025-04-19 Minor changes
2025-07-06 Adds net validation file
2025-07-06 Adds validation nets
2025-07-06 Adds validation code
2025-07-06 Fixes validation sheet mistakes
2025-08-17 Adds missing nets/links
2025-08-17 Adds net file (for validation)
2025-08-17 Fixes several mistakes (1 mistake in the schema!)
2025-08-17 Fixes most of the issues (GND and PWR still pending)
2025-08-17 Further validation sync
2025-08-17 Adds missing connection (PQ)
2025-08-18 Adds IC VCC/GND connections
2025-08-18 Fixes pad sizes
2025-08-19 Connectors double-checked
2025-08-19 Adds annotated schema
2025-08-20 Exports gerbers and drill files (B_PASTE, B_SILK, F_PASTE are empty)
2025-08-21 Rmv GINT-PIO connection (not there on the board)
2025-08-21 Updates gerber files
2025-08-23 Rmv obsolete copper layers
2025-08-25 Adds BOM
2025-10-26 Adds BOM files (WIP) and final layout
2025-10-27 Adds resistor values from reference board (schema values in brackets)
2026-05-28 Fixes IC5
2026-05-28 Updates PCB (from schema)
2026-05-28 Moves R49 to Sheet 14
2026-05-28 Detaches IC72/8 from ~{HCK}
2026-05-28 Rewires ~{HCK}
2026-05-28 Connects IC66/4 - IC67/7
2026-05-29 Minor change (consistency)
2026-06-02 Minor changes (consistency)
2026-06-02 Adds README.md
