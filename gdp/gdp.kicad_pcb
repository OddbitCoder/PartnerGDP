# Repository OddbitCoder/PartnerGDP

File README.md:

# GDP Component Tables

## Resistors

| ID | Schema | Original | Replica |
|----|--------|----------|---------|
| R1 | 1K | 1K | |
| R2 | 1K | 1K | |
| R3 | 1K | 1K | |
| R4 | 1K | 1K | |
| R5 | 1K | 1K | |
| R6 | 1K | 1K | |
| R7 | 2K2 | 2K2 | |
| R8 | 10K | 10K | |
| R9 | 10K | 10K | |
| R10 | 10K | 10K | 20K |
| R11 | 10K | 10K | |
| R12 | 10K | 10K | |
| R13 | 3K3 | 3K3 | |
| R14 | 2K2 | 2K2 | |
| R15 | 330 | 300 | |
| R16 | 2K2 | 2K2 | |
| R17 | 2K2 | 2K2 | |
| R18 | 2K2 | 2K2 | |
| R19 | 2K2 | 2K2 | |
| R20 | 2K2 | 2K2 | |
| R21 | 330 | 300 | |
| R22 | 2K2 | 2K2 | |
| R23 | 2K2 | 2K2 | |
| R24 | 120 | 120 | |
| R25 | 1K | 1K2 | |
| R26 | 47 | ? | |
| R27 | 220 | 220 | |
| R28 | 1K | 1K | |
| R29 | 220 | 220 | |
| R30 | 75 | 51 | |
| R31 | 75 | 75 | |
| R32 | 2K2 | 2K2 | |
| R33 | 2K2 | 2K2 | |
| R34 | 470 | 470 | |
| R35 | 2K2 | 2K2 | |
| R36 | 2K2 | 2K2 | |
| R37 | 1K5 | 1K5 | |
| R38 | 1K8 | 1K8 | |
| R39 | 180 | 180 | |
| R40 | 50 | 75 | |
| R41 | 1K2 | 1K2 | |
| R42 | 1K | 1K | |
| R43 | 680 | ? | |
| R44 | 1K5 | 1K5 | |
| R45 | 2K2 | 2K2 | |
| R46 | 1K2 | 1K2 | |
| R47 | 820 | N/A (composite monitor only) | |
| R48 | 1K | 1K | |
| R49 | 2K2 | 2K2 | |
| R50 | 470 | 510 | |
| R51 | 1K | 1K | |
| R52 | 2K2 | 2K2 | |
| R53 | 2K2 | 2K2 | |
| R54 | 470 | 510 | |
| R55 | N/A | 2K2 | |
| R56 | N/A | 2K2 | |

## Capacitors

| ID | Schema | Original | Replica |
|----|--------|----------|---------|
| CK1 | N/A | 0.1µF | 0.1µF |
| CK2 | N/A | 0.1µF | 0.1µF |
| CK3 | N/A | 0.1µF | 0.1µF |
| CK4 | N/A | 0.1µF | 0.1µF |
| CK5 | N/A | 0.1µF | 0.1µF |
| CK6 | N/A | 0.1µF | 0.1µF |
| CK7 | N/A | 0.1µF | 0.1µF |
| CK8 | N/A | 0.1µF | 0.1µF |
| CK9 | N/A | 0.1µF | 0.1µF |
| CK10 | N/A | 0.1µF | 0.1µF |
| CK11 | N/A | 0.1µF | 0.1µF |
| CK12 | N/A | 0.1µF | 0.1µF |
| CK13 | N/A | 0.1µF | 0.1µF |
| CK14 | N/A | 0.1µF | 0.1µF |
| CK15 | N/A | 0.1µF | 0.1µF |
| CK16 | N/A | 0.1µF | 0.1µF |
| CK17 | N/A | 0.1µF | 0.1µF |
| CK18 | N/A | 0.1µF | 0.1µF |
| CK19 | N/A | 0.1µF | 0.1µF |
| CK20 | N/A | 0.1µF | 0.1µF |
| CK21 | N/A | 0.1µF | 0.1µF |
| CK22 | N/A | 0.1µF | 0.1µF |
| CK23 | 10µF | 10µF 16V | |
| CK24 | N/A | 0.1µF | 0.1µF |
| CK25 | N/A | 0.1µF | 0.1µF |
| CK26 | N/A | 0.1µF | 0.1µF |
| CK27 | N/A | 0.1µF | 0.1µF |
| CK28 | N/A | 0.1µF | 0.1µF |
| CK29 | N/A | 0.1µF | 0.1µF |
| CK30 | N/A | 0.1µF | 0.1µF |
| CK31 | N/A | 0.1µF | 0.1µF |
| CK32 | N/A | 0.1µF | 0.1µF |
| CK33 | N/A | 0.1µF | 0.1µF |
| CK34 | N/A | 0.1µF | 0.1µF |
| CK35 | N/A | 0.1µF | 0.1µF |
| CK36 | N/A | 0.1µF | 0.1µF |
| CK37 | N/A | 0.1µF | 0.1µF |
| CK38 | N/A | 0.1µF | 0.1µF |
| CK39 | N/A | 0.1µF | 0.1µF |
| CK40 | N/A | 0.1µF | 0.1µF |
| CK41 | N/A | 0.1µF | 0.1µF |
| CK42 | N/A | 0.1µF | 0.1µF |
| CK43 | N/A | 0.1µF | 0.1µF |
| CK44 | N/A | 0.1µF | 0.1µF |
| CK45 | N/A | 0.1µF | 0.1µF |
| CK46 | N/A | 0.1µF | 0.1µF |
| CK47 | N/A | 0.1µF | 0.1µF |
| CK48 | N/A | 0.1µF | 0.1µF |
| CK49 | N/A | 0.1µF | 0.1µF |
| CK50 | N/A | 0.1µF | 0.1µF |
| CK51 | N/A | 0.1µF | 0.1µF |
| CK52 | 22pF | 22pF | |
| CK53 | 0.22µF | 0.1µF | |
| CK54 | N/A | 0.1µF | 0.1µF |
| CK55 | 2.2nF | 68pF (?) | |
| CK56 | N/A | 0.1µF | 0.1µF |
| CK57 | N/A | 0.1µF | 0.1µF |
| CK58 | N/A | 0.1µF | 0.1µF |
| CK59 | N/A | 0.1µF | 0.1µF |
| CK60 | N/A | 0.1µF | 0.1µF |
| CK61 | N/A | 0.1µF | 0.1µF |
| CK62 | 0.22µF | 0.22µF | |
| CK63 | 10pF | N/A | |
| CK64 | N/A | N/A | |
| CK65 | N/A | 22pF | |

# Diffs

The following differences were found between the original schema and the original board:

- The original schema does not contain decoupling capacitors. Most +5V/GND connections on ICs are also missing.
- AVDINT- is connected to ST8 (single-pin header), which is missing from the original schema.
- Pull-down resistors R55 and R56 for signal lines ATTD6 and ATTD7 are missing from the original schema.
- R32 is connected to +5V in the original schema but is connected to GND on the board.
- SH3 exists in the original schema but is not present on the board.
- GDP RAM pin numbers in the original schema are mostly incorrect.
- CK64 and CK65 are not in the original schema. CK64 is not installed on the original board; CK65 is a 22pF capacitor on the original board.
- IC17/8 is not connected to AVINT on the original board.
- IC17/9 is not connected to GINT on the original board.

# Mods

## HCK Mod

On the original board, the trace between IC67/7 and IC66/12 is physically cut by a drilled hole between IC66 and IC67. A wire is added from IC67/7 to IC66/4.

This mod is implemented in commits #3f22–#c79c.

## Video Output Stabilization Mod

The document (Odprava-napak-graficne-kartice.pdf, "Tresenje slike na graficnih PARTNERJIH") contains the following steps for stabilizing the text video output:

1. Carefully cut the PCB trace running from pin 13 of IC1 to the via. Be careful: the PCB is a four-layer board.
2. Connect pin 6 of IC11 to pin 8 of IC11.
3. Connect pin 8 of IC11 to pin 10 of IC11.
4. Connect pin 6 of IC11 to pin 9 of IC71.
5. Route the GDPSYNC signal from SH11 - the contact on the IC51 side - to pin 13 of IC51.
6. Connect pin 12 of IC51 to pin 5 of IC11.
7. Route the EOC signal from pin 15 of IC61 to pin 11 of IC51.
8. Connect pin 10 of IC51 to pin 9 of IC11.
9. Route the CLKEN signal from pin 8 of IC1 to pin 11 of IC11.
10. Install a resistor of approximately 300 Ω between pins 10 and 14 (+5 V) of IC11. Anything from 220 Ω to 470 Ω is acceptable.
11. Connect pin 13 of IC1 to pin 8 of IC71.

This mod is NOT implemented on the original board.

## Keyboard Comparator Threshold Mod

Replace R10 (10K) with a 20K resistor. Keep the TTL keyboard jumpers on ST3 (ST3/5–ST3/8 and ST3/6–ST3/7) as they are.

### Why

IC3A (LM393) receives keyboard data on ST3/4 and passes it to the motherboard on ST2/2.

- **IC3/3 (+ input):** keyboard data. R8/R9 (10K/10K) hold it at 2.5V when no keyboard is connected.
- **IC3/2 (− input):** reference level. In TTL mode, the jumpers connect it to R10 (10K to +5V) and R11 (10K to GND), so it also sits at 2.5V.

With the keyboard unplugged, both inputs are at 2.5V, so the output is undefined. It depends on part tolerances and noise. If it ends up low or switching, the motherboard sees a constant break or garbage on its keyboard input. The firmware then gets stuck and the AVDC text display does not work. The keyboard has to stay connected, or ST2 has to be unplugged.

The original board happens to settle high (idle), so it works by luck. The replica settled low.

Changing R10 to 20K lowers the reference on IC3/2 to about 1.7V:

- **Keyboard unplugged:** IC3/3 (2.5V) is clearly above IC3/2 (1.7V), so the output idles high (about 4.6V on IC3/1).
- **Keyboard connected:** 1.7V is close to the standard TTL threshold, so keyboard highs and lows are detected with good margin. The old 2.5V threshold was marginal even for valid TTL highs (2.4V minimum).

This mod is implemented on the replica board. It is NOT implemented on the original board and is not shown in the KiCad schematic.

## KiCad design gdp/gdp.kicad_pcb

Parts:
CK53: U22; C_Disc_D4.3mm_W1.9mm_P5.00mm
CK64, CK65: C_Disc_D4.3mm_W1.9mm_P5.00mm
IC63: 7406; DIP-14_W7.62mm
IC72: 74LS04; DIP-14_W7.62mm
R24: 120R; R_XL
R25: 1K2 (1K0); R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R29: 220R; R_XL
R30: 51R (75R); R_XL
R31: 75R; R_XL
R37, R44: 1K5; R_XL
R38: 1K8; R_XL
R39: 180R; R_XL
R40: 75R (50R); R_XL
R41, R46: 1K2; R_XL
R42: 1K0; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R43: 920R (680R); R_XL
R45: 2K2; R_XL
R47: 820R; R_XL
SH15, SH16, SH17, SH18, SH19: SCHALT; PinHeader_1x02_P2.54mm_Vertical
ST6: 3; PinHeader_1x03_P2.54mm_Vertical
ST7: 10; PinHeader_1x10_P2.54mm_Vertical
T1, T2: 2N2905A; T

Connections:
+5V: IC63.14 (VCC), IC72.14 (VCC); also elsewhere on the board
+12V: CK53.2, R29.1, R30.1, R39.1, R40.1, ST7.7; also elsewhere on the board
GND: CK53.1, IC63.7 (GND), IC72.7 (GND), R24.1, R31.2, SH15.2 (B), ST7.1, ST7.10; also elsewhere on the board
HCSYNC+: SH18.1 (A); also elsewhere on the board
unnamed: CK64.1, CK65.1, IC63.2, IC63.4, R42.1, R43.2
unnamed: IC63.1, IC72.6
unnamed: IC63.6, R37.2, R45.1
unnamed: IC63.8, R38.1, R46.2
unnamed: IC63.10, R25.2, R44.1
unnamed: IC63.12, R41.1, R47.2
unnamed: R31.1, SH15.1 (A), T2.1 (C)
unnamed: SH16.2 (B), SH17.2 (B), ST7.9
unnamed: SH18.2 (B), SH19.2 (B), ST7.6
unnamed: ST6.1, ST7.2
unnamed: ST6.2, ST7.3
unnamed: ST6.3, ST7.4
unnamed: R24.2, ST7.8, T1.1 (C)
unnamed: CK65.2, R25.1, R29.2, R37.1, R43.1, R46.1, R47.1, T1.2 (B)
unnamed: R30.2, T1.3 (E)
unnamed: CK64.2, R38.2, R39.2, R41.2, R42.2, R44.2, R45.2, T2.2 (B)
unnamed: R40.2, T2.3 (E)
TTLV1: IC63.11; also elsewhere on the board
TTLV2: IC63.3; also elsewhere on the board
VIDGP1: IC63.5; also elsewhere on the board
VIDGP2: IC63.9; also elsewhere on the board
VSYNC+: SH16.1 (A); also elsewhere on the board
~GVID: IC72.5; also elsewhere on the board
~HCSYNC: IC63.13, SH19.1 (A); also elsewhere on the board
~VSYNC: SH17.1 (A); also elsewhere on the board

Notes on the sheet:
ZA COMPOSITE
VIDEO MONITOR

Parts:
IC4: 74LS367; DIP-16_W7.62mm
IC5: SCN2674; DIP-40_W15.24mm
IC13: 74LS244; DIP-20_W7.62mm
IC16: 74LS245; DIP-20_W7.62mm
R1, R2, R3, R4, R5, R6: 1K0; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R16: 2K2; R_XL
RN1: 8x2K2; R_Array_SIP9

Connections:
+5V: IC4.16 (VCC), IC5.40 (VCC), IC13.20 (VCC), IC16.20 (VCC), R3.1, R5.1, R6.1, R16.1; also elsewhere on the board
A0: IC4.2 (I1); also elsewhere on the board
A1: IC4.4 (I2); also elsewhere on the board
A2: IC4.6 (I3); also elsewhere on the board
AHSYNC: IC5.19 (HSYNC); also elsewhere on the board
ASCD0: IC13.2 (I0); also elsewhere on the board
ASCD1: IC13.4 (I1); also elsewhere on the board
ASCD2: IC13.6 (I2); also elsewhere on the board
ASCD3: IC13.8 (I3); also elsewhere on the board
ASCD4: IC13.11 (I0); also elsewhere on the board
ASCD5: IC13.13 (I1); also elsewhere on the board
ASCD6: IC13.15 (I2); also elsewhere on the board
ASCD7: IC13.17 (I3); also elsewhere on the board
AVSCS: IC5.18 (V/CSYNC); also elsewhere on the board
BLANK: IC5.17 (BLANK); also elsewhere on the board
CURSOR: IC5.7 (CRS); also elsewhere on the board
D0: IC16.18 (B0); also elsewhere on the board
D1: IC16.17 (B1); also elsewhere on the board
D2: IC16.16 (B2); also elsewhere on the board
D3: IC16.15 (B3); also elsewhere on the board
D4: IC16.14 (B4); also elsewhere on the board
D5: IC16.13 (B5); also elsewhere on the board
D6: IC16.12 (B6); also elsewhere on the board
D7: IC16.11 (B7); also elsewhere on the board
DA0: IC5.34 (DA0/LG); also elsewhere on the board
DA1: IC5.33 (DA1/DA14); also elsewhere on the board
DA2: IC5.32 (DA2/DA15); also elsewhere on the board
DA3: IC5.31 (DA3/LR); also elsewhere on the board
DA4: IC5.30 (DA4/LA0); also elsewhere on the board
DA5: IC5.29 (DA5/LA1); also elsewhere on the board
DA6: IC5.28 (DA6/LA2); also elsewhere on the board
DA7: IC5.27 (DA7/LA3); also elsewhere on the board
DA8: IC5.26 (DA8/FL); also elsewhere on the board
DA9: IC5.25 (DA9/DW); also elsewhere on the board
DA10: IC5.24 (DA10/UL); also elsewhere on the board
DA11: IC5.23 (DA11/BLI); also elsewhere on the board
DA12: IC5.22 (DA12/ODD); also elsewhere on the board
DA13: IC5.21 (DA13/LL); also elsewhere on the board
GND: IC4.8 (GND), IC5.20 (GND), IC13.10 (GND), IC16.10 (GND), R1.1, R2.1, R4.1, RN1.1 (common); also elsewhere on the board
LROW: IC4.1 (OEa), IC4.15 (OEb); also elsewhere on the board
MASTER: IC5.36 (ACLL); also elsewhere on the board
unnamed: IC4.3 (O1a), IC5.37 (A0), R4.2
unnamed: IC4.5 (O2a), IC5.38 (A1), R3.2
unnamed: IC4.7 (O3a), IC5.39 (A2), R6.2
unnamed: IC4.9 (O4a), IC5.2 (CE), R1.2
unnamed: IC4.11 (O5b), IC5.1 (RD), R5.2
unnamed: IC4.13 (O6b), IC5.3 (WR), R2.2
unnamed: IC5.8 (D0), IC13.18 (O0), IC16.2 (A0), RN1.2 (R1)
unnamed: IC5.9 (D1), IC13.16 (O1), IC16.3 (A1), RN1.3 (R2)
unnamed: IC5.10 (D2), IC13.14 (O2), IC16.4 (A2), RN1.4 (R3)
unnamed: IC5.11 (D3), IC13.12 (O3), IC16.5 (A3), RN1.5 (R4)
unnamed: IC5.12 (D4), IC13.9 (O0), IC16.6 (A4), RN1.6 (R5)
unnamed: IC5.13 (D5), IC13.7 (O1), IC16.7 (A5), RN1.7 (R6)
unnamed: IC5.14 (D6), IC13.5 (O2), IC16.8 (A6), RN1.8 (R7)
unnamed: IC5.15 (D7), IC13.3 (O3), IC16.9 (A7), RN1.9 (R8)
~AVDC: IC4.10 (I4), IC16.19 (CE); also elsewhere on the board
~AVINT: IC5.35 (INTR), R16.2; also elsewhere on the board
~BCE: IC5.6 (CTRL3); also elsewhere on the board
~CCLK: IC5.16 (CCLK); also elsewhere on the board
~RDB: IC5.5 (CTRL2); also elsewhere on the board
~RD: IC4.12 (I5); also elsewhere on the board
~ROW: IC13.1 (~OE), IC13.19 (~OE); also elsewhere on the board
~WDB: IC5.4 (CTRL1); also elsewhere on the board
~WR: IC4.14 (I6), IC16.1 (A->B); also elsewhere on the board

Parts:
CK1, CK2, CK3, CK4, CK5, CK6, CK7, CK8, CK9, CK10, CK11, CK12, CK13, CK14, CK15, CK16, CK17, CK18, CK19, CK20, CK21, CK22, CK24, CK25, CK26, CK27, CK28, CK29, CK30, CK31, CK32, CK33, CK34, CK35, CK36, CK37, CK38, CK39, CK41, CK42, CK43, CK44, CK45, CK46, CK47, CK48, CK49, CK51, CK54, CK56, CK57, CK58, CK59, CK60, CK61: U10; C_Disc_D4.3mm_W1.9mm_P5.00mm
IC11: 7406; DIP-14_W7.62mm
IC51: 74LS14; DIP-14_W7.62mm
IC71: 74LS04; DIP-14_W7.62mm
R55, R56: 2K2; R_XL
ST8: Conn_01x01; PinHeader_1x01_P2.54mm_Vertical

Connections:
+5V: CK1.1, CK2.1, CK3.1, CK4.1, CK5.1, CK6.1, CK7.1, CK8.1, CK9.1, CK10.1, CK11.1, CK12.1, CK13.1, CK14.1, CK15.1, CK16.1, CK17.1, CK18.1, CK19.1, CK20.1, CK21.1, CK22.1, CK24.1, CK25.1, CK26.1, CK27.1, CK28.1, CK29.1, CK30.1, CK31.1, CK32.1, CK33.1, CK34.1, CK35.1, CK36.1, CK37.1, CK38.1, CK39.1, CK41.1, CK42.1, CK43.1, CK44.1, CK45.1, CK46.1, CK47.1, CK48.1, CK49.1, CK51.1, CK54.1, CK56.1, CK57.1, CK58.1, CK59.1, CK60.1, CK61.1; also elsewhere on the board
ATTD6: R56.1; also elsewhere on the board
ATTD7: R55.1; also elsewhere on the board
GND: CK1.2, CK2.2, CK3.2, CK4.2, CK5.2, CK6.2, CK7.2, CK8.2, CK9.2, CK10.2, CK11.2, CK12.2, CK13.2, CK14.2, CK15.2, CK16.2, CK17.2, CK18.2, CK19.2, CK20.2, CK21.2, CK22.2, CK24.2, CK25.2, CK26.2, CK27.2, CK28.2, CK29.2, CK30.2, CK31.2, CK32.2, CK33.2, CK34.2, CK35.2, CK36.2, CK37.2, CK38.2, CK39.2, CK41.2, CK42.2, CK43.2, CK44.2, CK45.2, CK46.2, CK47.2, CK48.2, CK49.2, CK51.2, CK54.2, CK56.2, CK57.2, CK58.2, CK59.2, CK60.2, CK61.2, R55.2, R56.2; also elsewhere on the board
~AVDINT: ST8.1; also elsewhere on the board

Parts:
IC19, IC20, IC44, IC45: HM6116; DIP-24_W15.24mm

Connections:
+5V: IC19.24 (VCC), IC20.24 (VCC), IC44.24 (VCC), IC45.24 (VCC); also elsewhere on the board
ASCD0: IC19.9 (D0), IC20.9 (D0); also elsewhere on the board
ASCD1: IC19.10 (D1), IC20.10 (D1); also elsewhere on the board
ASCD2: IC19.11 (D2), IC20.11 (D2); also elsewhere on the board
ASCD3: IC19.13 (D3), IC20.13 (D3); also elsewhere on the board
ASCD4: IC19.14 (D4), IC20.14 (D4); also elsewhere on the board
ASCD5: IC19.15 (D5), IC20.15 (D5); also elsewhere on the board
ASCD6: IC19.16 (D6), IC20.16 (D6); also elsewhere on the board
ASCD7: IC19.17 (D7), IC20.17 (D7); also elsewhere on the board
ATTD0: IC44.9 (D0), IC45.9 (D0); also elsewhere on the board
ATTD1: IC44.10 (D1), IC45.10 (D1); also elsewhere on the board
ATTD2: IC44.11 (D2), IC45.11 (D2); also elsewhere on the board
ATTD3: IC44.13 (D3), IC45.13 (D3); also elsewhere on the board
ATTD4: IC44.14 (D4), IC45.14 (D4); also elsewhere on the board
ATTD5: IC44.15 (D5), IC45.15 (D5); also elsewhere on the board
ATTD6: IC44.16 (D6), IC45.16 (D6); also elsewhere on the board
ATTD7: IC44.17 (D7), IC45.17 (D7); also elsewhere on the board
DA0: IC19.8 (A0), IC20.8 (A0), IC44.8 (A0), IC45.8 (A0); also elsewhere on the board
DA1: IC19.7 (A1), IC20.7 (A1), IC44.7 (A1), IC45.7 (A1); also elsewhere on the board
DA2: IC19.6 (A2), IC20.6 (A2), IC44.6 (A2), IC45.6 (A2); also elsewhere on the board
DA3: IC19.5 (A3), IC20.5 (A3), IC44.5 (A3), IC45.5 (A3); also elsewhere on the board
DA4: IC19.4 (A4), IC20.4 (A4), IC44.4 (A4), IC45.4 (A4); also elsewhere on the board
DA5: IC19.3 (A5), IC20.3 (A5), IC44.3 (A5), IC45.3 (A5); also elsewhere on the board
DA6: IC19.2 (A6), IC20.2 (A6), IC44.2 (A6), IC45.2 (A6); also elsewhere on the board
DA7: IC19.1 (A7), IC20.1 (A7), IC44.1 (A7), IC45.1 (A7); also elsewhere on the board
DA8: IC19.23 (A8), IC20.23 (A8), IC44.23 (A8), IC45.23 (A8); also elsewhere on the board
DA9: IC19.22 (A9), IC20.22 (A9), IC44.22 (A9), IC45.22 (A9); also elsewhere on the board
DA10: IC19.19 (A10), IC20.19 (A10), IC44.19 (A10), IC45.19 (A10); also elsewhere on the board
GND: IC19.12 (GND), IC19.20 (~OE), IC20.12 (GND), IC20.20 (~OE), IC44.12 (GND), IC44.20 (~OE), IC45.12 (GND), IC45.20 (~OE); also elsewhere on the board
~CHR: IC19.18 (~CS), IC44.18 (~CS); also elsewhere on the board
~CLR: IC20.18 (~CS), IC45.18 (~CS); also elsewhere on the board
~WDB: IC19.21 (~WE), IC20.21 (~WE), IC44.21 (~WE), IC45.21 (~WE); also elsewhere on the board

Parts:
CK50: U10; C_Disc_D4.3mm_W1.9mm_P5.00mm
CK55: 2N2; C_Disc_D4.3mm_W1.9mm_P5.00mm
IC1: 74LS74; DIP-14_W7.62mm
IC12: PAL16R4; DIP-20_W7.62mm
IC51: 74LS14; DIP-14_W7.62mm
IC64: 74LS123; DIP-16_W7.62mm
IC66: 74S00; DIP-14_W7.62mm
IC71: 74LS04; DIP-14_W7.62mm
R17: 2K2; R_XL
R27: 220R; R_XL_narrow
R48: 1K0; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SH4, SH5, SH6, SH10, SH11, SH12, SH13, SH14: SCHALT; PinHeader_1x02_P2.54mm_Vertical

Connections:
+5V: IC1.10 (~S), IC1.12 (D), IC1.14 (VCC), IC12.20 (VCC), IC51.14 (VCC), IC64.11 (Clr), IC64.16 (VCC), IC66.14 (VCC), IC71.14 (VCC), R17.2, R48.2, SH6.1 (A); also elsewhere on the board
AHSYNC: SH5.1 (A); also elsewhere on the board
ATTD2: IC12.8 (I7); also elsewhere on the board
AVSCS: SH10.1 (A), SH14.1 (A); also elsewhere on the board
BLANK: IC66.2, IC71.3; also elsewhere on the board
CCLK+: IC12.1 (CLK), IC71.6; also elsewhere on the board
CLKEN: IC1.8 (~Q); also elsewhere on the board
CURSOR: IC66.1; also elsewhere on the board
DA11: IC12.3 (I2); also elsewhere on the board
DA12: IC12.4 (I3); also elsewhere on the board
DA13: IC12.5 (I4); also elsewhere on the board
GDPSYNC: SH11.1 (A); also elsewhere on the board
GND: CK50.2, IC1.7 (GND), IC12.10 (GND), IC12.11 (~OE), IC51.7 (GND), IC64.8 (GND), IC64.9 (A), IC66.7 (GND), IC71.7 (GND), SH4.1 (A); also elsewhere on the board
HCSYNC+: IC51.5, SH10.2 (B), SH11.2 (B); also elsewhere on the board
LROW: IC64.5 (Q); also elsewhere on the board
MASTER: SH6.2 (B), SH12.2 (B); also elsewhere on the board
unnamed: CK50.1, IC51.1, R27.1
unnamed: IC1.11 (C), SH4.2 (B), SH5.2 (B)
unnamed: IC12.9 (I8), R17.1
unnamed: IC64.10 (B), SH13.2 (B), SH14.2 (B)
unnamed: CK55.1, IC64.6 (Cext)
unnamed: CK55.2, IC64.7 (RCext), R48.1
VSYNC+: IC51.2, IC51.3, SH12.1 (A), SH13.1 (A); also elsewhere on the board
~AVDINT: IC12.15 (Q3); also elsewhere on the board
~AVINT: IC12.2 (I1); also elsewhere on the board
~BCE: IC12.6 (I5); also elsewhere on the board
~BLNK: IC71.4; also elsewhere on the board
~CCLK: IC71.5; also elsewhere on the board
~CHR: IC12.19 (IO1); also elsewhere on the board
~CLR: IC12.18 (IO2); also elsewhere on the board
~CRAMEN: IC12.16 (Q2); also elsewhere on the board
~CRAM: IC12.13 (IO3); also elsewhere on the board
~CROM: IC12.17 (Q1); also elsewhere on the board
~DSPEN: IC71.2; also elsewhere on the board
~HCSYNC: IC1.13 (~R), IC51.6, R27.2; also elsewhere on the board
~LDEN: IC12.12 (IO4), IC71.1; also elsewhere on the board
~ROW: IC66.3; also elsewhere on the board
~VSYNC: IC51.4; also elsewhere on the board
~WDB: IC12.7 (I6); also elsewhere on the board

Parts:
IC1: 74LS74; DIP-14_W7.62mm
IC2: 74LS42; DIP-16_W7.62mm
IC9, IC21, IC28, IC35, IC48: 74LS374; DIP-20_W7.62mm
IC15: 74LS367; DIP-16_W7.62mm

Connections:
+5V: IC1.1 (~R), IC1.4 (~S), IC2.16 (VCC), IC9.20 (VCC), IC15.16 (VCC), IC21.20 (VCC), IC28.20 (VCC), IC35.20 (VCC), IC48.20 (VCC); also elsewhere on the board
A0: IC2.15 (A0); also elsewhere on the board
A1: IC2.14 (A1); also elsewhere on the board
ASCD0: IC21.3, IC28.2; also elsewhere on the board
ASCD1: IC21.4, IC28.5; also elsewhere on the board
ASCD2: IC21.7, IC28.6; also elsewhere on the board
ASCD3: IC21.8, IC28.9; also elsewhere on the board
ASCD4: IC21.13, IC28.12; also elsewhere on the board
ASCD5: IC21.14, IC28.15; also elsewhere on the board
ASCD6: IC21.17, IC28.16; also elsewhere on the board
ASCD7: IC21.18, IC28.19; also elsewhere on the board
ATTD0: IC35.2, IC48.3; also elsewhere on the board
ATTD1: IC35.5, IC48.4; also elsewhere on the board
ATTD2: IC35.6, IC48.7; also elsewhere on the board
ATTD3: IC35.9, IC48.8; also elsewhere on the board
ATTD4: IC35.12, IC48.13; also elsewhere on the board
ATTD5: IC35.15, IC48.14; also elsewhere on the board
ATTD6: IC35.16, IC48.17; also elsewhere on the board
ATTD7: IC35.19, IC48.18; also elsewhere on the board
D0: IC9.3, IC21.2, IC28.3, IC35.3, IC48.2; also elsewhere on the board
D1: IC9.4, IC21.5, IC28.4, IC35.4, IC48.5; also elsewhere on the board
D2: IC9.7, IC21.6, IC28.7, IC35.7, IC48.6; also elsewhere on the board
D3: IC9.8, IC21.9, IC28.8, IC35.8, IC48.9; also elsewhere on the board
D4: IC9.13, IC15.11 (2Y1), IC21.12, IC28.13, IC35.13, IC48.12; also elsewhere on the board
D5: IC9.14, IC21.15, IC28.14, IC35.14, IC48.15; also elsewhere on the board
D6: IC9.17, IC21.16, IC28.17, IC35.17, IC48.16; also elsewhere on the board
D7: IC9.18, IC15.13 (2Y2), IC21.19, IC28.18, IC35.18, IC48.19; also elsewhere on the board
DOUT: IC1.2 (D); also elsewhere on the board
GND: IC2.8 (GND), IC9.1 (~G2), IC9.10 (GND), IC15.8 (GND), IC21.10 (GND), IC28.10 (GND), IC35.10 (GND), IC48.10 (GND); also elsewhere on the board
LOAD: IC1.3 (C); also elsewhere on the board
unnamed: IC2.1 (0), IC28.11 (C1)
unnamed: IC2.2 (1), IC35.11 (C1)
unnamed: IC2.3 (2), IC9.11 (C1)
unnamed: IC2.5 (4), IC21.1 (~G2)
unnamed: IC2.6 (5), IC48.1 (~G2)
unnamed: IC1.5 (Q), IC15.14 (2I2)
unnamed: IC2.7 (6), IC15.15 (~2G)
SCRL0: IC9.2; also elsewhere on the board
SCRL1: IC9.5; also elsewhere on the board
SCRL2: IC9.6; also elsewhere on the board
SCRL3: IC9.9; also elsewhere on the board
SCRL4: IC9.12; also elsewhere on the board
SCRL5: IC9.15; also elsewhere on the board
SCRL6: IC9.16; also elsewhere on the board
SCRL7: IC9.19; also elsewhere on the board
~BUFFER: IC2.12 (A3); also elsewhere on the board
~RDB: IC21.11 (C1), IC48.11 (C1); also elsewhere on the board
~RESTRICT: IC15.12 (2I1); also elsewhere on the board
~WDB: IC28.1 (~G2), IC35.1 (~G2); also elsewhere on the board
~WR: IC2.13 (A2); also elsewhere on the board
