# Repository OddbitCoder/PartnerGDP (continued)

## KiCad design gdp/gdp.kicad_pcb (continued)

Parts:
IC22: PAL16L8; DIP-20_W7.62mm
IC23: EF9367; DIP-40_W15.24mm
IC24: PAL10L8; DIP-20_W7.62mm
IC49: PAL16R4; DIP-20_W7.62mm
R7, R52: 2K2; R_XL
R22, R23, R36: 2K2; R_XL_narrow

Connections:
+5V: IC22.20 (VCC), IC23.40 (VCC), IC24.20 (VCC), IC49.20 (VCC), R22.2, R23.2, R36.1, R52.2; also elsewhere on the board
A0: IC23.9 (A0); also elsewhere on the board
A1: IC23.10 (A1); also elsewhere on the board
A2: IC23.11 (A2); also elsewhere on the board
A3: IC23.12 (A3); also elsewhere on the board
ALL1: IC24.14 (O6); also elsewhere on the board
D0: IC23.33 (D0); also elsewhere on the board
D1: IC23.32 (D1); also elsewhere on the board
D2: IC23.31 (D2); also elsewhere on the board
D3: IC23.30 (D3); also elsewhere on the board
D4: IC23.29 (D4); also elsewhere on the board
D5: IC23.28 (D5); also elsewhere on the board
D6: IC23.27 (D6); also elsewhere on the board
D7: IC23.26 (D7); also elsewhere on the board
DAD0: IC23.37 (DAD0); also elsewhere on the board
DAD1: IC23.39 (DAD1); also elsewhere on the board
DAD2: IC23.38 (DAD2); also elsewhere on the board
DAD3: IC23.4 (DAD3); also elsewhere on the board
DAD4: IC23.3 (DAD4); also elsewhere on the board
DAD5: IC23.2 (DAD5), IC49.2 (I1); also elsewhere on the board
DAD6: IC23.5 (DAD6), IC49.3 (I2); also elsewhere on the board
DOUT: IC24.5 (I5), IC24.15 (O5); also elsewhere on the board
DOUT1: IC24.3 (I3); also elsewhere on the board
DOUT2: IC24.4 (I4); also elsewhere on the board
EOC: IC22.11 (I10); also elsewhere on the board
FM0: IC22.7 (I7); also elsewhere on the board
FM1: IC22.8 (I8); also elsewhere on the board
GA7: IC49.18 (IO2); also elsewhere on the board
GDPSYNC: IC23.34 (SYNC); also elsewhere on the board
GND: IC22.10 (GND), IC23.20 (GND), IC23.23 (W0), IC24.10 (GND), IC49.10 (GND), IC49.11 (~OE), R7.1; also elsewhere on the board
LOAD: IC22.17 (I02); also elsewhere on the board
LPEN: IC23.21 (LPCK), R7.2; also elsewhere on the board
MUX1: IC24.2 (I2), IC49.4 (I3); also elsewhere on the board
unnamed: IC22.1 (I1), IC23.14 (DW)
unnamed: IC22.2 (I2), IC23.24 (MW)
unnamed: IC22.9 (I9), IC23.25 (BLK), IC49.5 (I4)
unnamed: IC22.18 (IO1), IC23.8 (FMAT)
unnamed: IC23.15 (DIN), IC24.7 (I7)
unnamed: IC23.35 (MSL3), IC49.6 (I5)
unnamed: IC24.8 (I8), R23.1
unnamed: IC24.9 (I9), R22.1
unnamed: IC24.11 (I10), R52.1
PO: IC49.19 (IO1); also elsewhere on the board
QA: IC22.4 (I4); also elsewhere on the board
QB: IC22.5 (I5); also elsewhere on the board
QC: IC22.6 (I6), IC23.1 (CK), IC49.1 (CLK); also elsewhere on the board
RBNK: IC49.7 (I6); also elsewhere on the board
SCRLM: IC49.9 (I8); also elsewhere on the board
SHLD: IC22.19 (O1); also elsewhere on the board
SOUT: IC49.13 (IO3); also elsewhere on the board
WBNK: IC49.8 (I7); also elsewhere on the board
X0: IC23.6 (MSL0); also elsewhere on the board
X1: IC23.36 (MSL1); also elsewhere on the board
X2: IC23.7 (MSL2); also elsewhere on the board
X3: IC49.17 (Q1); also elsewhere on the board
X9: IC23.19 (X9); also elsewhere on the board
XORM: IC24.6 (I6); also elsewhere on the board
~ALL16: IC22.14 (IO5); also elsewhere on the board
~ALL: IC22.3 (I3), IC23.22 (ALL), IC24.1 (I1); also elsewhere on the board
~CAS: IC22.15 (IO4); also elsewhere on the board
~DINX: IC24.16 (O4); also elsewhere on the board
~ENS: IC22.13 (IO6); also elsewhere on the board
~GDPINT: IC49.14 (Q4); also elsewhere on the board
~GDP: IC23.17 (E); also elsewhere on the board
~GINT: IC23.13 (IRQ), IC49.12 (IO4), R36.2; also elsewhere on the board
~NORM: IC24.13 (O7); also elsewhere on the board
~SHIFT: IC24.12 (O8); also elsewhere on the board
~WHITE: IC22.12 (O2); also elsewhere on the board
~WRITE: IC22.16 (IO3); also elsewhere on the board
~WR: IC23.18 (R/W); also elsewhere on the board

Parts:
CK52: 22P; C_Disc_D4.3mm_W1.9mm_P5.00mm
CK62: 22U; C_Disc_D4.3mm_W1.9mm_P5.00mm
CK63: 10P; C_Disc_D4.3mm_W1.9mm_P5.00mm
IC51: 74LS14; DIP-14_W7.62mm
IC52: 74LS00; DIP-14_W7.62mm
IC61: 74LS163; DIP-16_W7.62mm
IC64: 74LS123; DIP-16_W7.62mm
IC65: 74LS74; DIP-14_W7.62mm
IC66: 74S00; DIP-14_W7.62mm
IC72: 74LS04; DIP-14_W7.62mm
O1: Crystal; Crystal_HC50_Horizontal
R28: 1K0; R_S
R34: 470R; R_XL_narrow
R49: 2K2; R_XL
R50, R54: 510R (470R); R_XL
R51: 1K0; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal

Connections:
+5V: IC52.14 (VCC), IC61.9 (~PE), IC61.16 (VCC), IC64.3 (Clr), IC65.1 (~R), IC65.4 (~S), IC65.10 (~S), IC65.13 (~R), IC65.14 (VCC), R34.2, R51.1; also elsewhere on the board
CA7: IC52.4, IC72.11; also elsewhere on the board
CLKEN: IC52.2; also elsewhere on the board
DCLK: IC52.3; also elsewhere on the board
EOC: IC61.15 (TC); also elsewhere on the board
GND: CK63.2, IC52.7 (GND), IC61.3 (D0), IC61.4 (D1), IC61.5 (D2), IC61.6 (D3), IC61.8 (GND), IC65.7 (GND), R28.1, R49.2; also elsewhere on the board
MUX1: IC65.8 (~Q); also elsewhere on the board
unnamed: CK62.1, IC72.12, R50.2
unnamed: CK62.2, IC72.1, R54.1
unnamed: CK63.1, IC72.13, O1.1, R50.1
unnamed: IC51.8, IC52.12
unnamed: IC52.1, IC52.8
unnamed: IC52.6, IC52.9
unnamed: IC52.10, IC52.11
unnamed: IC52.13, IC72.10
unnamed: IC61.1 (~MR), IC61.7 (CEP), IC61.10 (CET), R51.2
unnamed: IC64.1 (A), IC64.13 (Q), IC65.3 (C)
unnamed: IC64.2 (B), IC66.8
unnamed: CK52.1, IC64.14 (Cext)
unnamed: CK52.2, IC64.15 (RCext), R34.1
unnamed: IC51.9, IC64.4 (~Q)
unnamed: IC65.2 (D), IC65.6 (~Q), IC66.13
unnamed: IC65.5 (Q), IC66.5
unnamed: IC66.6, IC66.9
unnamed: IC66.10, IC66.11
unnamed: IC66.12, IC72.8, R49.1
unnamed: IC72.2, IC72.3, O1.2, R54.2
QA: IC61.13 (Q1), IC65.11 (C); also elsewhere on the board
QB: IC61.12 (Q2); also elsewhere on the board
QC: IC61.11 (Q3), IC65.12 (D); also elsewhere on the board
~HCK: IC52.5, IC61.2 (CP), IC66.4, IC72.4, IC72.9, R28.2; also elsewhere on the board

Schematic: 10.kicad_sch, PARTNER GDP: CHAR GEN + CMAC

Parts:
CK40: U10; C_Disc_D4.3mm_W1.9mm_P5.00mm
IC46: 2732; DIP-24_W15.24mm
IC47: HM6116; DIP-24_W15.24mm
IC50: SCB2675; DIP-40_W15.24mm
R26: 47R; R_XXL
R32, R33: 2K2; R_L
R35: 2K2; R_XL

Connections:
+5V: IC46.24 (VCC), IC47.24 (VCC), IC50.40 (VCC), R26.1, R33.2, R35.2; also elsewhere on the board
ADOUBLE: IC50.14 (ADBL); also elsewhere on the board
ATTD0: IC50.16 (ABLNK); also elsewhere on the board
ATTD1: IC50.19 (AVL); also elsewhere on the board
ATTD4: IC50.25 (ARF); also elsewhere on the board
ATTD5: IC50.18 (AGB); also elsewhere on the board
ATTD6: IC50.22 (ABB); also elsewhere on the board
ATTD7: IC50.21 (ARB); also elsewhere on the board
BLANK: IC50.12 (BLNK); also elsewhere on the board
CA0: IC50.10 (DOTS); also elsewhere on the board
CA1: IC50.9 (CMODE); also elsewhere on the board
CA2: IC50.30 (M/C); also elsewhere on the board
CA3: IC50.23 (ABF); also elsewhere on the board
CA4: IC50.17 (AGF); also elsewhere on the board
CA5: IC50.34 (C0); also elsewhere on the board
CA6: IC50.35 (C1); also elsewhere on the board
CH0: IC46.8 (A0), IC47.8 (A0); also elsewhere on the board
CH1: IC46.7 (A1), IC47.7 (A1); also elsewhere on the board
CH2: IC46.6 (A2), IC47.6 (A2); also elsewhere on the board
CH3: IC46.5 (A3), IC47.5 (A3); also elsewhere on the board
CH4: IC46.4 (A4), IC47.4 (A4); also elsewhere on the board
CH5: IC46.3 (A5), IC47.3 (A5); also elsewhere on the board
CH6: IC46.2 (A6), IC47.2 (A6); also elsewhere on the board
CH7: IC46.1 (A7), IC47.1 (A7); also elsewhere on the board
CH8: IC46.23 (A8), IC47.23 (A8); also elsewhere on the board
CH9: IC46.22 (A9), IC47.22 (A9); also elsewhere on the board
CH10: IC46.19 (A10), IC47.19 (A10); also elsewhere on the board
CH11: IC46.21 (A11); also elsewhere on the board
CHD0: IC46.9 (D0), IC47.9 (D0), IC50.39 (D0); also elsewhere on the board
CHD1: IC46.10 (D1), IC47.10 (D1), IC50.2 (D1); also elsewhere on the board
CHD2: IC46.11 (D2), IC47.11 (D2), IC50.38 (D2); also elsewhere on the board
CHD3: IC46.13 (D3), IC47.13 (D3), IC50.3 (D3); also elsewhere on the board
CHD4: IC46.14 (D4), IC47.14 (D4), IC50.37 (D4); also elsewhere on the board
CHD5: IC46.15 (D5), IC47.15 (D5), IC50.4 (D5); also elsewhere on the board
CHD6: IC46.16 (D6), IC47.16 (D6), IC50.36 (D6); also elsewhere on the board
CHD7: IC46.17 (D7), IC47.17 (D7), IC50.5 (D7), IC50.6 (D8); also elsewhere on the board
CURSOR: IC50.8 (CRS); also elsewhere on the board
DA10: IC50.13 (UL); also elsewhere on the board
DA11: IC50.11 (BLINK); also elsewhere on the board
DCLK: IC50.32 (DCLK); also elsewhere on the board
GND: CK40.2, IC46.12 (GND), IC47.12 (GND), IC50.15 (RSET), IC50.20 (GND), R32.2; also elsewhere on the board
unnamed: IC50.24 (ADOTM), R35.1
unnamed: IC50.31 (DOTM), R32.1
unnamed: IC50.7 (RBLNK), R33.1
unnamed: CK40.1, IC50.1 (VBB), R26.2
TTLV1: IC50.28 (R/T1); also elsewhere on the board
TTLV2: IC50.29 (B/T2); also elsewhere on the board
VIDGP1: IC50.27 (G/G1); also elsewhere on the board
VIDGP2: IC50.26 (L/G2); also elsewhere on the board
~CCLK: IC50.33 (~CCLK); also elsewhere on the board
~CRAMEN: IC47.20 (~OE); also elsewhere on the board
~CRAM: IC47.18 (~CS); also elsewhere on the board
~CROM: IC46.18 (~CS), IC46.20 (~OE); also elsewhere on the board
~WDB: IC47.21 (~WE); also elsewhere on the board

Schematic: 5.kicad_sch, PARTNER GDP: MEMOUT + RAS/SELECT

Parts:
IC29, IC30: 74LS538; DIP-20_W7.62mm
IC67, IC69: 74LS166; DIP-16_W7.62mm
IC68, IC70: 74LS30; DIP-14_W7.62mm
R53: 2K2; R_XL
RN2, RN3: 8x2K2; R_Array_SIP9

Connections:
+5V: IC29.20 (VCC), IC30.20 (VCC), IC67.1 (Ds), IC67.16 (VCC), IC68.14 (VCC), IC69.16 (VCC), IC70.14 (VCC), RN2.1 (common), RN3.1 (common); also elsewhere on the board
ALL1: IC29.15 (G3); also elsewhere on the board
DOUT1: IC70.8; also elsewhere on the board
DOUT2: IC68.8; also elsewhere on the board
GDO0: IC69.14 (H), IC70.3, RN3.7 (R1); also elsewhere on the board
GDO1: IC69.12 (G), IC70.2, RN3.3 (R2); also elsewhere on the board
GDO2: IC69.11 (F), IC70.6, RN3.8 (R3); also elsewhere on the board
GDO3: IC69.10 (E), IC70.11, RN3.5 (R4); also elsewhere on the board
GDO4: IC69.5 (D), IC70.5, RN3.6 (R5); also elsewhere on the board
GDO5: IC69.4 (C), IC70.4, RN3.9 (R6); also elsewhere on the board
GDO6: IC69.3 (B), IC70.12, RN3.4 (R7); also elsewhere on the board
GDO7: IC69.2 (A), IC70.1, RN3.2 (R8); also elsewhere on the board
GDO8: IC67.14 (H), IC68.12, RN2.4 (R1); also elsewhere on the board
GDO9: IC67.12 (G), IC68.11, RN2.7 (R2); also elsewhere on the board
GDO10: IC67.11 (F), IC68.5, RN2.6 (R3); also elsewhere on the board
GDO11: IC67.10 (E), IC68.4, RN2.8 (R4); also elsewhere on the board
GDO12: IC67.5 (D), IC68.6, RN2.9 (R5); also elsewhere on the board
GDO13: IC67.4 (C), IC68.2, RN2.5 (R6); also elsewhere on the board
GDO14: IC67.3 (B), IC68.3, RN2.2 (R7); also elsewhere on the board
GDO15: IC67.2 (A), IC68.1, RN2.3 (R8); also elsewhere on the board
GND: IC29.4 (OE1), IC29.5 (OE2), IC29.10 (GND), IC30.4 (OE1), IC30.5 (OE2), IC30.10 (GND), IC67.6 (CE), IC67.8 (GND), IC68.7 (GND), IC69.6 (CE), IC69.8 (GND), IC70.7 (GND), R53.2; also elsewhere on the board
unnamed: IC67.13 (Qh), IC69.1 (Ds)
QC: IC29.14 (G2), IC30.14 (G2); also elsewhere on the board
RAS0: IC30.3 (Y0); also elsewhere on the board
RAS1: IC30.2 (Y1); also elsewhere on the board
RAS2: IC30.1 (Y2); also elsewhere on the board
RAS3: IC30.19 (Y3); also elsewhere on the board
RAS4: IC30.18 (Y4); also elsewhere on the board
RAS5: IC30.8 (Y5); also elsewhere on the board
RAS6: IC30.9 (Y6); also elsewhere on the board
RAS7: IC30.11 (Y7); also elsewhere on the board
RAS8: IC29.3 (Y0); also elsewhere on the board
RAS9: IC29.2 (Y1); also elsewhere on the board
RAS10: IC29.1 (Y2); also elsewhere on the board
RAS11: IC29.19 (Y3); also elsewhere on the board
RAS12: IC29.18 (Y4); also elsewhere on the board
RAS13: IC29.8 (Y5); also elsewhere on the board
RAS14: IC29.9 (Y6); also elsewhere on the board
RAS15: IC29.11 (Y7); also elsewhere on the board
SHLD: IC67.15 (PE), IC69.15 (PE), R53.1; also elsewhere on the board
X0: IC29.6 (A), IC30.6 (A); also elsewhere on the board
X1: IC29.7 (B), IC30.7 (B); also elsewhere on the board
X2: IC29.17 (C), IC30.17 (C); also elsewhere on the board
X3: IC29.13 (G1), IC30.15 (G3); also elsewhere on the board
~ALL16: IC29.12 (AL), IC30.12 (AL); also elsewhere on the board
~ALL: IC30.13 (G1); also elsewhere on the board
~ENS: IC29.16 (G4), IC30.16 (G4); also elsewhere on the board
~GVID: IC69.13 (Qh); also elsewhere on the board
~HCK: IC67.7 (Clk), IC69.7 (Clk); also elsewhere on the board
~WHITE: IC67.9 (Clr), IC69.9 (Clr); also elsewhere on the board

Schematic: 6.kicad_sch, PARTNER GDP: GDP SCROLL + CAS MUX

Parts:
IC10, IC14: 74LS83; DIP-16_W7.62mm
IC18, IC25, IC32: 74LS244; DIP-20_W7.62mm

Connections:
+5V: IC10.5 (VCC), IC14.5 (VCC), IC18.20 (VCC), IC25.20 (VCC), IC32.20 (VCC); also elsewhere on the board
DAD0: IC14.1 (A4), IC32.4 (I1), IC32.11 (I0); also elsewhere on the board
DAD1: IC14.3 (A3), IC32.6 (I2), IC32.13 (I1); also elsewhere on the board
DAD2: IC14.8 (A2), IC32.8 (I3), IC32.15 (I2); also elsewhere on the board
DAD3: IC14.10 (A1), IC25.2 (I0), IC32.17 (I3); also elsewhere on the board
DAD4: IC10.1 (A4), IC18.2 (I0), IC25.4 (I1); also elsewhere on the board
DAD5: IC10.3 (A3), IC18.4 (I1); also elsewhere on the board
DAD6: IC10.8 (A2); also elsewhere on the board
GA0: IC18.7 (O1), IC18.14 (O2), IC25.14 (O2); also elsewhere on the board
GA1: IC18.5 (O2), IC18.16 (O1), IC25.16 (O1); also elsewhere on the board
GA2: IC18.3 (O3), IC18.18 (O0), IC25.18 (O0); also elsewhere on the board
GA3: IC25.9 (O0), IC32.3 (O3), IC32.12 (O3); also elsewhere on the board
GA4: IC25.7 (O1), IC32.5 (O2), IC32.14 (O2); also elsewhere on the board
GA5: IC25.5 (O2), IC32.7 (O1), IC32.16 (O1); also elsewhere on the board
GA6: IC25.3 (O3), IC32.9 (O0), IC32.18 (O0); also elsewhere on the board
GND: IC10.12 (GND), IC10.13 (C0), IC14.12 (GND), IC18.8 (I3), IC18.10 (GND), IC18.11 (I0), IC25.8 (I3), IC25.10 (GND), IC32.10 (GND); also elsewhere on the board
MUX1: IC18.19 (~OE), IC25.19 (~OE); also elsewhere on the board
unnamed: IC10.14 (C4), IC14.13 (C0)
unnamed: IC10.9 (S1), IC18.6 (I2), IC25.6 (I2)
unnamed: IC10.6 (S2), IC18.13 (I1)
unnamed: IC10.2 (S3), IC18.15 (I2)
unnamed: IC10.15 (S4), IC18.17 (I3)
unnamed: IC14.9 (S1), IC25.11 (I0)
unnamed: IC14.6 (S2), IC25.13 (I1)
unnamed: IC14.2 (S3), IC25.15 (I2)
unnamed: IC14.15 (S4), IC25.17 (I3)
PO: IC10.10 (A1); also elsewhere on the board
SCRL0: IC10.11 (B1); also elsewhere on the board
SCRL1: IC10.7 (B2); also elsewhere on the board
SCRL2: IC10.4 (B3); also elsewhere on the board
SCRL3: IC10.16 (B4); also elsewhere on the board
SCRL4: IC14.11 (B1); also elsewhere on the board
SCRL5: IC14.7 (B2); also elsewhere on the board
SCRL6: IC14.4 (B3); also elsewhere on the board
SCRL7: IC14.16 (B4); also elsewhere on the board
SOUT: IC14.14 (C4); also elsewhere on the board
X9: IC32.2 (I0); also elsewhere on the board
~NORM: IC18.1 (~OE), IC32.19 (~OE); also elsewhere on the board
~SHIFT: IC25.1 (~OE), IC32.1 (~OE); also elsewhere on the board

Schematic: 11.kicad_sch, PARTNER GDP: CHAR DATA

Parts:
IC15: 74LS367; DIP-16_W7.62mm
IC26, IC27: 74LS374; DIP-20_W7.62mm
IC33, IC34: 74LS244; DIP-20_W7.62mm

Connections:
+5V: IC15.16 (VCC), IC26.20 (VCC), IC27.20 (VCC), IC33.20 (VCC), IC34.20 (VCC); also elsewhere on the board
ADOUBLE: IC26.2 (O0); also elsewhere on the board
ASCD0: IC27.3 (D0), IC34.11 (I0); also elsewhere on the board
ASCD1: IC27.4 (D1), IC34.13 (I1); also elsewhere on the board
ASCD2: IC27.7 (D2), IC34.15 (I2); also elsewhere on the board
ASCD3: IC27.8 (D3), IC34.17 (I3); also elsewhere on the board
ASCD4: IC27.13 (D4), IC33.11 (I0); also elsewhere on the board
ASCD5: IC27.14 (D5), IC33.13 (I1); also elsewhere on the board
ASCD6: IC27.17 (D6), IC33.15 (I2); also elsewhere on the board
ASCD7: IC27.18 (D7), IC33.17 (I3); also elsewhere on the board
CCLK+: IC27.11 (Cp); also elsewhere on the board
CH0: IC15.3 (1Y1), IC26.12 (O4); also elsewhere on the board
CH1: IC15.5 (1Y2), IC26.15 (O5); also elsewhere on the board
CH2: IC15.7 (1Y3), IC26.16 (O6); also elsewhere on the board
CH3: IC15.9 (1Y4), IC26.19 (O7); also elsewhere on the board
CH4: IC27.2 (O0), IC33.18 (O0); also elsewhere on the board
CH5: IC27.5 (O1), IC33.16 (O1); also elsewhere on the board
CH6: IC27.6 (O2), IC33.14 (O2); also elsewhere on the board
CH7: IC27.9 (O3), IC33.12 (O3); also elsewhere on the board
CH8: IC27.12 (O4), IC34.18 (O0); also elsewhere on the board
CH9: IC27.15 (O5), IC34.16 (O1); also elsewhere on the board
CH10: IC27.16 (O6), IC34.14 (O2); also elsewhere on the board
CH11: IC27.19 (O7), IC34.12 (O3); also elsewhere on the board
CHD0: IC34.9 (O0); also elsewhere on the board
CHD1: IC34.7 (O1); also elsewhere on the board
CHD2: IC34.5 (O2); also elsewhere on the board
CHD3: IC34.3 (O3); also elsewhere on the board
CHD4: IC33.9 (O0); also elsewhere on the board
CHD5: IC33.7 (O1); also elsewhere on the board
CHD6: IC33.5 (O2); also elsewhere on the board
CHD7: IC33.3 (O3); also elsewhere on the board
DA0: IC15.2 (1I1); also elsewhere on the board
DA1: IC15.4 (1I2), IC26.7 (D2); also elsewhere on the board
DA2: IC15.6 (1I3), IC26.8 (D3); also elsewhere on the board
DA3: IC15.10 (1I4); also elsewhere on the board
DA4: IC26.13 (D4), IC33.2 (I0); also elsewhere on the board
DA5: IC26.14 (D5), IC33.4 (I1); also elsewhere on the board
DA6: IC26.17 (D6), IC33.6 (I2); also elsewhere on the board
DA7: IC26.18 (D7), IC33.8 (I3); also elsewhere on the board
DA8: IC34.2 (I0); also elsewhere on the board
DA9: IC26.3 (D0), IC34.4 (I1); also elsewhere on the board
DA10: IC34.6 (I2); also elsewhere on the board
DA11: IC34.8 (I3); also elsewhere on the board
DA13: IC26.4 (D1); also elsewhere on the board
GND: IC15.8 (GND), IC26.10 (GND), IC27.10 (GND), IC33.10 (GND), IC34.10 (GND); also elsewhere on the board
~BLNK: IC26.11 (Cp); also elsewhere on the board
~DSPEN: IC26.1 (OE), IC27.1 (OE); also elsewhere on the board
~LDEN: IC15.1 (~1G), IC33.1 (~OE), IC33.19 (~OE), IC34.1 (~OE), IC34.19 (~OE); also elsewhere on the board
~RESTRICT: IC26.5 (O1); also elsewhere on the board

Schematic: 4.kicad_sch, PARTNER GDP: GDP RAM

Parts:
IC36, IC37, IC38, IC39, IC40, IC41, IC42, IC43, IC53, IC54, IC55, IC56, IC57, IC58, IC59, IC60: 4164-15; DIP-16_W7.62mm

Connections:
+5V: IC36.8 (VCC), IC37.8 (VCC), IC38.8 (VCC), IC39.8 (VCC), IC40.8 (VCC), IC41.8 (VCC), IC42.8 (VCC), IC43.8 (VCC), IC53.8 (VCC), IC54.8 (VCC), IC55.8 (VCC), IC56.8 (VCC), IC57.8 (VCC), IC58.8 (VCC), IC59.8 (VCC), IC60.8 (VCC); also elsewhere on the board
GA0: IC36.5 (A0), IC37.5 (A0), IC38.5 (A0), IC39.5 (A0), IC40.5 (A0), IC41.5 (A0), IC42.5 (A0), IC43.5 (A0), IC53.5 (A0), IC54.5 (A0), IC55.5 (A0), IC56.5 (A0), IC57.5 (A0), IC58.5 (A0), IC59.5 (A0), IC60.5 (A0); also elsewhere on the board
GA1: IC36.7 (A1), IC37.7 (A1), IC38.7 (A1), IC39.7 (A1), IC40.7 (A1), IC41.7 (A1), IC42.7 (A1), IC43.7 (A1), IC53.7 (A1), IC54.7 (A1), IC55.7 (A1), IC56.7 (A1), IC57.7 (A1), IC58.7 (A1), IC59.7 (A1), IC60.7 (A1); also elsewhere on the board
GA2: IC36.6 (A2), IC37.6 (A2), IC38.6 (A2), IC39.6 (A2), IC40.6 (A2), IC41.6 (A2), IC42.6 (A2), IC43.6 (A2), IC53.6 (A2), IC54.6 (A2), IC55.6 (A2), IC56.6 (A2), IC57.6 (A2), IC58.6 (A2), IC59.6 (A2), IC60.6 (A2); also elsewhere on the board
GA3: IC36.12 (A3), IC37.12 (A3), IC38.12 (A3), IC39.12 (A3), IC40.12 (A3), IC41.12 (A3), IC42.12 (A3), IC43.12 (A3), IC53.12 (A3), IC54.12 (A3), IC55.12 (A3), IC56.12 (A3), IC57.12 (A3), IC58.12 (A3), IC59.12 (A3), IC60.12 (A3); also elsewhere on the board
GA4: IC36.11 (A4), IC37.11 (A4), IC38.11 (A4), IC39.11 (A4), IC40.11 (A4), IC41.11 (A4), IC42.11 (A4), IC43.11 (A4), IC53.11 (A4), IC54.11 (A4), IC55.11 (A4), IC56.11 (A4), IC57.11 (A4), IC58.11 (A4), IC59.11 (A4), IC60.11 (A4); also elsewhere on the board
GA5: IC36.10 (A5), IC37.10 (A5), IC38.10 (A5), IC39.10 (A5), IC40.10 (A5), IC41.10 (A5), IC42.10 (A5), IC43.10 (A5), IC53.10 (A5), IC54.10 (A5), IC55.10 (A5), IC56.10 (A5), IC57.10 (A5), IC58.10 (A5), IC59.10 (A5), IC60.10 (A5); also elsewhere on the board
GA6: IC36.13 (A6), IC37.13 (A6), IC38.13 (A6), IC39.13 (A6), IC40.13 (A6), IC41.13 (A6), IC42.13 (A6), IC43.13 (A6), IC53.13 (A6), IC54.13 (A6), IC55.13 (A6), IC56.13 (A6), IC57.13 (A6), IC58.13 (A6), IC59.13 (A6), IC60.13 (A6); also elsewhere on the board
GA7: IC36.9 (A7), IC37.9 (A7), IC38.9 (A7), IC39.9 (A7), IC40.9 (A7), IC41.9 (A7), IC42.9 (A7), IC43.9 (A7), IC53.9 (A7), IC54.9 (A7), IC55.9 (A7), IC56.9 (A7), IC57.9 (A7), IC58.9 (A7), IC59.9 (A7), IC60.9 (A7); also elsewhere on the board
GDO0: IC40.14 (DOUT); also elsewhere on the board
GDO1: IC59.14 (DOUT); also elsewhere on the board
GDO2: IC57.14 (DOUT); also elsewhere on the board
GDO3: IC60.14 (DOUT); also elsewhere on the board
GDO4: IC58.14 (DOUT); also elsewhere on the board
GDO5: IC42.14 (DOUT); also elsewhere on the board
GDO6: IC43.14 (DOUT); also elsewhere on the board
GDO7: IC41.14 (DOUT); also elsewhere on the board
GDO8: IC54.14 (DOUT); also elsewhere on the board
GDO9: IC39.14 (DOUT); also elsewhere on the board
GDO10: IC36.14 (DOUT); also elsewhere on the board
GDO11: IC37.14 (DOUT); also elsewhere on the board
GDO12: IC53.14 (DOUT); also elsewhere on the board
GDO13: IC38.14 (DOUT); also elsewhere on the board
GDO14: IC55.14 (DOUT); also elsewhere on the board
GDO15: IC56.14 (DOUT); also elsewhere on the board
GND: IC36.16 (GND), IC37.16 (GND), IC38.16 (GND), IC39.16 (GND), IC40.16 (GND), IC41.16 (GND), IC42.16 (GND), IC43.16 (GND), IC53.16 (GND), IC54.16 (GND), IC55.16 (GND), IC56.16 (GND), IC57.16 (GND), IC58.16 (GND), IC59.16 (GND), IC60.16 (GND); also elsewhere on the board
RAS0: IC40.4 (~RAS); also elsewhere on the board
RAS1: IC59.4 (RAS); also elsewhere on the board
RAS2: IC57.4 (RAS); also elsewhere on the board
RAS3: IC60.4 (RAS); also elsewhere on the board
RAS4: IC58.4 (RAS); also elsewhere on the board
RAS5: IC42.4 (RAS); also elsewhere on the board
RAS6: IC43.4 (RAS); also elsewhere on the board
RAS7: IC41.4 (RAS); also elsewhere on the board
RAS8: IC54.4 (RAS); also elsewhere on the board
RAS9: IC39.4 (RAS); also elsewhere on the board
RAS10: IC36.4 (RAS); also elsewhere on the board
RAS11: IC37.4 (RAS); also elsewhere on the board
RAS12: IC53.4 (RAS); also elsewhere on the board
RAS13: IC38.4 (RAS); also elsewhere on the board
RAS14: IC55.4 (RAS); also elsewhere on the board
RAS15: IC56.4 (RAS); also elsewhere on the board
~CAS: IC36.15 (CAS), IC37.15 (CAS), IC38.15 (CAS), IC39.15 (CAS), IC40.15 (~CAS), IC41.15 (CAS), IC42.15 (CAS), IC43.15 (CAS), IC53.15 (CAS), IC54.15 (CAS), IC55.15 (CAS), IC56.15 (CAS), IC57.15 (CAS), IC58.15 (CAS), IC59.15 (CAS), IC60.15 (CAS); also elsewhere on the board
~DINX: IC36.2 (DIN), IC37.2 (DIN), IC38.2 (DIN), IC39.2 (DIN), IC40.2 (DIN), IC41.2 (DIN), IC42.2 (DIN), IC43.2 (DIN), IC53.2 (DIN), IC54.2 (DIN), IC55.2 (DIN), IC56.2 (DIN), IC57.2 (DIN), IC58.2 (DIN), IC59.2 (DIN), IC60.2 (DIN); also elsewhere on the board
~WRITE: IC36.3 (WR), IC37.3 (WR), IC38.3 (WR), IC39.3 (WR), IC40.3 (~WR), IC41.3 (WR), IC42.3 (WR), IC43.3 (WR), IC53.3 (WR), IC54.3 (WR), IC55.3 (WR), IC56.3 (WR), IC57.3 (WR), IC58.3 (WR), IC59.3 (WR), IC60.3 (WR); also elsewhere on the board

Schematic: 2.kicad_sch, PARTNER GDP: ADRESIRANJE + PIO

Parts:
IC6: 74LS85; DIP-16_W7.62mm
IC7: PAL16L8; DIP-20_W7.62mm
IC17: MK3881; DIP-40_W15.24mm
R18, R19, R20: 2K2; R_XL
SH7, SH8, SH9: SCHALT; PinHeader_1x02_P2.54mm_Vertical

Connections:
+5V: IC6.3 (i(A=B)), IC6.16 (VCC), IC7.20 (VCC), IC17.26 (VCC), SH7.2 (B), SH8.2 (B), SH9.2 (B); also elsewhere on the board
/2/unconnected-IC6-5: IC6.5 (A>B)
/2/unconnected-IC6-7: IC6.7 (A<B)
A0: IC17.5 (DS); also elsewhere on the board
A1: IC17.6 (BAS); also elsewhere on the board
A2: IC7.3 (C); also elsewhere on the board
A3: IC7.4 (D); also elsewhere on the board
A4: IC7.5 (E); also elsewhere on the board
A5: IC6.11 (B1); also elsewhere on the board
A6: IC6.14 (B2); also elsewhere on the board
A7: IC6.1 (B3); also elsewhere on the board
CA0: IC17.27 (B0); also elsewhere on the board
CA1: IC17.28 (B1); also elsewhere on the board
CA2: IC17.29 (B2); also elsewhere on the board
CA3: IC17.30 (B3); also elsewhere on the board
CA4: IC17.31 (B4); also elsewhere on the board
CA5: IC17.32 (B5); also elsewhere on the board
CA6: IC17.33 (B6); also elsewhere on the board
CA7: IC17.34 (B7); also elsewhere on the board
D0: IC17.19 (D0); also elsewhere on the board
D1: IC17.20 (D1); also elsewhere on the board
D2: IC17.1 (D2); also elsewhere on the board
D3: IC17.40 (D3); also elsewhere on the board
D4: IC17.39 (D4); also elsewhere on the board
D5: IC17.38 (D5); also elsewhere on the board
D6: IC17.3 (D6); also elsewhere on the board
D7: IC17.2 (D7); also elsewhere on the board
FM0: IC17.12 (A3); also elsewhere on the board
FM1: IC17.10 (A4); also elsewhere on the board
GND: IC6.2 (i(A<B)), IC6.4 (i(A>B)), IC6.8 (GND), IC6.9 (B0), IC6.10 (A0), IC7.10 (GND), IC17.11 (GND), R18.1, R19.1, R20.1; also elsewhere on the board
IEI: IC17.24 (INI); also elsewhere on the board
unnamed: IC6.12 (A1), R19.2, SH7.1 (A)
unnamed: IC6.13 (A2), R18.2, SH8.1 (A)
unnamed: IC6.15 (A3), R20.2, SH9.1 (A)
unnamed: IC6.6 (A=B), IC7.1 (A)
unnamed: IC7.14 (BC), IC17.4 (~CE)
unnamed: IC7.17 (BF), IC17.37 (~M1)
PHI: IC17.25 (PHI); also elsewhere on the board
RBNK: IC17.15 (A0); also elsewhere on the board
SCRLM: IC17.7 (A7); also elsewhere on the board
WBNK: IC17.14 (A1); also elsewhere on the board
XORM: IC17.13 (A2); also elsewhere on the board
~AVDC: IC7.16 (BE); also elsewhere on the board
~AVDINT: IC17.17 (~BSTB); also elsewhere on the board
~AVINT: IC17.8 (A6); also elsewhere on the board
~BUFFER: IC7.15 (BD); also elsewhere on the board
~DIN: IC7.18 (BG); also elsewhere on the board
~GDPINT: IC17.16 (~ASTB); also elsewhere on the board
~GDP: IC7.12 (ZA); also elsewhere on the board
~GINT: IC17.9 (A5); also elsewhere on the board
~INT: IC7.8 (H), IC17.23 (~INT); also elsewhere on the board
~IORQ: IC7.9 (I), IC17.36 (~IORQ); also elsewhere on the board
~M1: IC7.7 (G); also elsewhere on the board
~RD: IC7.6 (F), IC17.35 (~RD); also elsewhere on the board
~RES: IC7.2 (B); also elsewhere on the board
~TSC: IC7.13 (BB); also elsewhere on the board

Notes on the sheet:
IE0

Schematic: 1.kicad_sch, PARTNER GDP: BUS + KEYBOARD INTERFACE

Parts:
CK23: 10U; CP_Radial_Tantal_D6.0mm_P5.00mm
IC3: LM393; DIP-8_W7.62mm
IC8: 74LS245; DIP-20_W7.62mm
IC11: 7406; DIP-14_W7.62mm
R8, R9, R10, R11, R12: 10K; R_XL
R13: 3K3; R_XL
R14: 2K2; R_XL
R15, R21: 300R (330R); R_XL
SH1, SH2, SH3: SCHALT; PinHeader_1x02_P2.54mm_Vertical
ST1: 6; PWR
ST2: 6; PinHeader_1x06_P2.54mm_Vertical
ST3: 10; PinHeader_1x10_P2.54mm_Vertical
ST4, ST5: 32; PinHeader_1x32_P2.54mm_Vertical

Connections:
+5V: CK23.1, IC3.8 (V+), IC8.20 (VCC), IC11.14 (VCC), R9.1, R10.1, R13.1, R15.1, R21.2, SH1.2 (B), ST1.2, ST1.4, ST3.1; also elsewhere on the board
+12V: SH3.2 (B), ST1.6; also elsewhere on the board
A0: ST5.17; also elsewhere on the board
A1: ST5.18; also elsewhere on the board
A2: ST5.19; also elsewhere on the board
A3: ST5.20; also elsewhere on the board
A4: ST5.21; also elsewhere on the board
A5: ST5.22; also elsewhere on the board
A6: ST5.23; also elsewhere on the board
A7: ST5.24; also elsewhere on the board
D0: IC8.18 (B0); also elsewhere on the board
D0B: IC8.2 (A0), ST4.25
D1: IC8.17 (B1); also elsewhere on the board
D1B: IC8.3 (A1), ST4.26
D2: IC8.16 (B2); also elsewhere on the board
D2B: IC8.4 (A2), ST4.27
D3: IC8.15 (B3); also elsewhere on the board
D3B: IC8.5 (A3), ST4.28
D4: IC8.14 (B4); also elsewhere on the board
D4B: IC8.6 (A4), ST4.29
D5: IC8.13 (B5); also elsewhere on the board
D5B: IC8.7 (A5), ST4.30
D6: IC8.12 (B6); also elsewhere on the board
D6B: IC8.8 (A6), ST4.31
D7: IC8.11 (B7); also elsewhere on the board
D7B: IC8.9 (A7), ST4.32
GND: CK23.2, IC3.4 (V-), IC3.5 (+), IC3.6 (-), IC8.10 (GND), IC8.19 (~CE), IC11.7 (GND), R8.1, SH2.2 (B), ST1.1, ST1.3, ST2.1, ST2.4, ST3.8, ST4.1, ST4.2, ST5.1, ST5.2; also elsewhere on the board
IEI: ST4.8; also elsewhere on the board
LPEN: SH2.1 (A); also elsewhere on the board
unnamed: IC3.3 (+), R8.2, R9.2, ST3.4
unnamed: IC3.2 (-), R11.2, ST3.6
unnamed: IC3.1, R13.2, ST2.2
unnamed: IC11.1, ST2.3
unnamed: IC11.2, IC11.3, R12.2, R14.2, R21.1, ST3.2
unnamed: R12.1, ST3.3
unnamed: R11.1, R14.1, ST3.5
unnamed: R10.2, ST3.7
unnamed: IC11.4, R15.2, ST3.9
PHI: ST4.17; also elsewhere on the board
VCC: SH1.1 (A), ST4.4, ST4.5, ST5.4, ST5.5
VDD: SH3.1 (A), ST4.6, ST5.6
~DIN: ST4.22; also elsewhere on the board
~INT: ST4.15; also elsewhere on the board
~IORQ: ST4.18; also elsewhere on the board
~M1: ST5.12; also elsewhere on the board
~RD: ST5.16; also elsewhere on the board
~RES: ST4.11; also elsewhere on the board
~TSC: IC8.1 (~DIR); also elsewhere on the board
~WR: ST4.19; also elsewhere on the board
